# Keil uVision project acm_drive.uvprojx, settings and files
target acmdr (6190000::V6.19::ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: SL216X +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Source Files
    ./: acm_dr.c io.c arcode_lop.h com.c com.h sound.c sound.h spi_transfer.c spi_transfer.h
  group Library
    ./Library/StdDriver/src/: sys.c clk.c timer.c spi.c fmc.c gpio.c usci_uart.c wdt.c pwm.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.00.001
